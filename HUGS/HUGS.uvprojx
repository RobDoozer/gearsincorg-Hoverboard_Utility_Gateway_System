# Keil uVision project HUGS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HUGS +hex
  AfterMake: C:\Keil_v5\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./Src/: main.c bldc.c setup.c it.c comms.c commsSteering.c led.c commsHUGS.c
  group Inc
    ./Inc/: defines.h config.h bldc.h setup.h it.h comms.h commsSteering.h led.h commsHUGS.h
target GD32E230C8T6 (6230000::V6.23::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: HUGS +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: GD32E230
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.4.0, Device:GD32E23x_StdPeripherals:ADC 1.0.0, Device:GD32E23x_StdPeripherals:CMP 1.0.0, Device:GD32E23x_StdPeripherals:CRC 1.0.0, Device:GD32E23x_StdPeripherals:DBG 1.0.0, Device:GD32E23x_StdPeripherals:DMA 1.0.0, Device:GD32E23x_StdPeripherals:EXTI 1.0.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:FWDGT 1.0.0, Device:GD32E23x_StdPeripherals:GPIO 1.0.0, Device:GD32E23x_StdPeripherals:I2C 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:PMU 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_StdPeripherals:RTC 1.0.0, Device:GD32E23x_StdPeripherals:SPI_I2S 1.0.0, Device:GD32E23x_StdPeripherals:SYSCFG 1.0.0, Device:GD32E23x_StdPeripherals:TIMER 1.0.0, Device:GD32E23x_StdPeripherals:USART 1.0.0, Device:GD32E23x_StdPeripherals:WWDGT 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:GD32F1x0_StdPeripherals:ADC 3.1.0, Device:GD32F1x0_StdPeripherals:DMA 3.1.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.1.0, Device:GD32F1x0_StdPeripherals:GPIO 3.1.0, Device:GD32F1x0_StdPeripherals:I2C 3.1.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.1.0, Device:GD32F1x0_StdPeripherals:MISC 3.1.0, Device:GD32F1x0_StdPeripherals:OPA 3.1.0, Device:GD32F1x0_StdPeripherals:PMU 3.1.0, Device:GD32F1x0_StdPeripherals:RCU 3.1.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.1.0, Device:GD32F1x0_StdPeripherals:TIMER 3.1.0, Device:GD32F1x0_StdPeripherals:USART 3.1.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.1.0, Device:GD32F1x0_libopt 3.1.0, Device:Startup 1.0.0, Device:Startup 3.1.0
